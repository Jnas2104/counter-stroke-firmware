## boards/shields/tt_zaehler/Kconfig.defconfig
```kconfig
if SHIELD_TT_ZAEHLER

config ZMK_KEYBOARD_NAME
    default "CounterStroke"

endif
```
